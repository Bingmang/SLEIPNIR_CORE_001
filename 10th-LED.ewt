<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>RAM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>FLASH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>source</name>
    <group>
      <name>ccdcollect</name>
      <file>
        <name>$PROJ_DIR$\source\ccdcollect\ccdcollect.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\ccdcollect\ccdcollect.h</name>
      </file>
    </group>
    <group>
      <name>ccdidentify</name>
      <file>
        <name>$PROJ_DIR$\source\ccdidentify\ccdidentify.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\ccdidentify\ccdidentify.h</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\source\common\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\common\print.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\common\print.h</name>
      </file>
    </group>
    <group>
      <name>cpu</name>
      <file>
        <name>$PROJ_DIR$\source\cpu\clkinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\clkinit.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\core.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\start.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\start.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\vectors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\cpu\vectors.h</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <file>
        <name>$PROJ_DIR$\source\drivers\adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\interrupt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\interrupt.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\math.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\math.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\mcg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\mcg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\pulse_counter.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\pulse_counter.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\pwm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\pwm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\wdog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\drivers\wdog.h</name>
      </file>
    </group>
    <group>
      <name>link</name>
      <file>
        <name>$PROJ_DIR$\source\link\Pflash.icf</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\link\Ram.icf</name>
      </file>
    </group>
    <group>
      <name>pid</name>
      <file>
        <name>$PROJ_DIR$\source\pid\pid.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\pid\pid.h</name>
      </file>
    </group>
    <group>
      <name>schedule</name>
      <file>
        <name>$PROJ_DIR$\source\schedule\schedule.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\schedule\schedule.h</name>
      </file>
    </group>
    <group>
      <name>systeminit</name>
      <file>
        <name>$PROJ_DIR$\source\systeminit\systeminit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\source\systeminit\systeminit.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\source\main.c</name>
    </file>
  </group>
</project>


