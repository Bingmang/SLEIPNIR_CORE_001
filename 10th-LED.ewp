# IAR project 10th-LED.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 10th-LED.srec
  ILINK.IlinkOutputFile: 10th-LED.out
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 Freescale MK66FN2M0xxx18
  ICCARM.CCIncludePath2: source; source\common; source\cpu; source\drivers; source\schedule
  ILINK.IlinkIcfFile: source\link\Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group source
    source/: main.c
  group source/ccdcollect
    source/ccdcollect/: ccdcollect.c ccdcollect.h
  group source/ccdidentify
    source/ccdidentify/: ccdidentify.c ccdidentify.h
  group source/common
    source/common/: common.h print.c print.h
  group source/cpu
    source/cpu/: clkinit.c clkinit.h core.c core.h crt0.s start.c start.h vectors.c vectors.h
  group source/drivers
    source/drivers/: adc.c adc.h gpio.c gpio.h interrupt.c interrupt.h math.c math.h mcg.c mcg.h pulse_counter.c pulse_counter.h pwm.c pwm.h timer.c timer.h uart.c uart.h wdog.c wdog.h
  group source/link
    source/link/: Pflash.icf Ram.icf
  group source/pid
    source/pid/: pid.c pid.h
  group source/schedule
    source/schedule/: schedule.c schedule.h
  group source/systeminit
    source/systeminit/: systeminit.c systeminit.h
